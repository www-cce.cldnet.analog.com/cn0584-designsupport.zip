# Allegro board CN0584 Allegro Project.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SCL: length 18.6
  TOP w0.2: v1(78.88,13.75) 79.2,14.08 P1.A49
  BOTTOM w0.2: U1.6 69.37,9.38 70.25,8.5 74.12,8.5 75.12,7.5 76.75,7.5 78.88,9.62 v1(78.88,13.75)
SDA: length 19.5
  TOP w0.2: P1.A50 79.69,13.44 v1(79.5,13.25)
  BOTTOM w0.2: U1.5 68.09,9.91 70,8 73.88,8 74.88,7 77,7 79.5,9.5 v1(79.5,13.25)
UNNAMED_1_ADA4898_I21_INVA: length 6.3
  TOP w0.2: v2(59.42,44.13) 59.16,43.87 R14A.2 58,43.87 56.62,42.5 C3A.1 54.18,42.77 v2(54.08,42.87)
UNNAMED_1_ADA4898_I21_INVB: length 6.3
  TOP w0.2: v2(59.42,32.14) 59.16,31.87 R14B.2 58,31.87 56.62,30.5 C3B.1 54.18,30.77 v2(54.08,30.86)
UNNAMED_1_ADA4898_I21_INVC: length 6.3
  TOP w0.2: v2(54.08,18.87) 54.18,18.77 C3C.1 56.62,18.5 58,19.87 R14C.2 59.16,19.87 v2(59.42,20.14)
UNNAMED_1_ADA4898_I21_INVD: length 6.3
  TOP w0.2: v2(54.08,6.87) 54.18,6.77 C3D.1 56.62,6.5 58,7.87 R14D.2 59.16,7.87 v2(59.42,8.13)
UNNAMED_1_ADA4898_I21_NINVA: length 2.9
  TOP w0.2: v2(54.08,44.13) 54.02,44.07 C5A.2 52.38,44.07 52.18,43.88 R8A.2
UNNAMED_1_ADA4898_I21_NINVB: length 2.9
  TOP w0.2: R8B.2 52.18,31.88 52.38,32.07 C5B.2 54.02,32.07 v2(54.08,32.14)
UNNAMED_1_ADA4898_I21_NINVC: length 2.9
  TOP w0.2: R8C.2 52.18,19.88 52.38,20.07 C5C.2 54.02,20.07 v2(54.08,20.14)
UNNAMED_1_ADA4898_I21_NINVD: length 2.9
  TOP w0.2: R8D.2 52.18,7.88 52.38,8.07 C5D.2 54.02,8.07 v2(54.08,8.13)
UNNAMED_1_ADA4898_I21_PDNA: length 2
  BOTTOM w0.25: U3A.8 60.53,41.59 R13A.2
UNNAMED_1_ADA4898_I21_PDNB: length 2
  BOTTOM w0.25: R13B.2 60.53,29.59 U3B.8
UNNAMED_1_ADA4898_I21_PDNC: length 2
  BOTTOM w0.25: U3C.8 60.53,17.59 R13C.2
UNNAMED_1_ADA4898_I21_PDND: length 2
  BOTTOM w0.25: 59.42,5.59 60.53,5.59 R13D.2
UNNAMED_1_ADA4898_I40_INVA: length 5.9
  TOP w0.2: v2(59.42,50.13) 59.16,49.88 R15A.1 58,49.88 56.99,48.87 v2(54.08,48.87) 54.06,48.87 C4A.1
UNNAMED_1_ADA4898_I40_INVB: length 5.9
  TOP w0.2: v2(59.42,38.13) 59.16,37.88 R15B.1 58,37.88 56.99,36.87 v2(54.08,36.87) 54.06,36.87 C4B.1
UNNAMED_1_ADA4898_I40_INVC: length 5.9
  TOP w0.2: v2(59.42,26.14) 59.16,25.88 R15C.1 58,25.88 56.99,24.86 v2(54.08,24.86) 54.06,24.86 C4C.1
UNNAMED_1_ADA4898_I40_INVD: length 5.9
  TOP w0.2: v2(59.42,14.13) 59.16,13.88 R15D.1 58,13.88 56.99,12.87 v2(54.08,12.87) 54.06,12.87 C4D.1
UNNAMED_1_ADA4898_I40_NINVA: length 3.1
  TOP w0.2: v2(54.08,50.13) 53.87,50.35 52.62,50.35 ; 52.62,50.35 52.52,50.25 R9A.2 ; 52.62,50.35 C6A.2
UNNAMED_1_ADA4898_I40_NINVB: length 3.1
  TOP w0.2: 52.62,38.35 52.52,38.25 R9B.2 ; 52.62,38.35 C6B.2 ; 52.62,38.35 53.87,38.35 v2(54.08,38.13)
UNNAMED_1_ADA4898_I40_NINVC: length 3.1
  TOP w0.2: v2(54.08,26.14) 53.87,26.35 52.62,26.35 ; 52.62,26.35 C6C.2 ; 52.62,26.35 52.52,26.25 R9C.2
UNNAMED_1_ADA4898_I40_NINVD: length 3.1
  TOP w0.2: 52.62,14.35 C6D.2 ; 52.62,14.35 52.52,14.25 R9D.2 ; 52.62,14.35 53.87,14.35 v2(54.08,14.13)
UNNAMED_1_ADA4898_I40_PDNA: length 1.7
  BOTTOM w0.2: U2A.8 61.03,47.59 R12A.2
UNNAMED_1_ADA4898_I40_PDNB: length 1.7
  BOTTOM w0.2: R12B.2 61.03,35.59 U2B.8
UNNAMED_1_ADA4898_I40_PDNC: length 1.7
  BOTTOM w0.2: U2C.8 61.03,23.59 R12C.2
UNNAMED_1_ADA4898_I40_PDND: length 1.7
  BOTTOM w0.2: R12D.2 61.03,11.59 U2D.8
UNNAMED_1_ADG5421F_I60_D1A: length 4.6
  TOP w0.2: R2A.2 v1(46.75,47.5) R4A.1
  BOTTOM w0.2: U1A.10 46.25,48 v1(46.75,47.5)
UNNAMED_1_ADG5421F_I60_D1B: length 4.6
  TOP w0.2: R2B.2 v1(46.75,35.5) R4B.1
  BOTTOM w0.2: v1(46.75,35.5) 46.25,36 U1B.10
UNNAMED_1_ADG5421F_I60_D1C: length 4.6
  TOP w0.2: R2C.2 v1(46.75,23.5) R4C.1
  BOTTOM w0.2: v1(46.75,23.5) 46.25,24 U1C.10
UNNAMED_1_ADG5421F_I60_D1D: length 4.6
  TOP w0.2: R2D.2 v1(46.75,11.5) R4D.1
  BOTTOM w0.2: U1D.10 46.25,12 v1(46.75,11.5)
UNNAMED_1_ADG5421F_I60_D2A: length 4.5
  TOP w0.2: R5A.2 v1(46.75,48.75) 46.73,48.77 45.89,48.77 45.75,48.62 R3A.2
  BOTTOM w0.2: U1A.9 46.5,48.5 v1(46.75,48.75)
UNNAMED_1_ADG5421F_I60_D2B: length 4.5
  TOP w0.2: R5B.2 v1(46.75,36.75) 46.73,36.77 46.02,36.77 45.88,36.62 R3B.2
  BOTTOM w0.2: v1(46.75,36.75) 46.5,36.5 U1B.9
UNNAMED_1_ADG5421F_I60_D2C: length 4.5
  TOP w0.2: R3C.2 46,24.62 46.14,24.77 46.73,24.77 v1(46.75,24.75) R5C.2
  BOTTOM w0.2: U1C.9 46.5,24.5 v1(46.75,24.75)
UNNAMED_1_ADG5421F_I60_D2D: length 4.5
  TOP w0.2: R3D.2 45.75,12.62 45.88,12.75 v1(46.75,12.75) R5D.2
  BOTTOM w0.2: U1D.9 46.5,12.5 v1(46.75,12.75)
UNNAMED_1_CAP_I16_N2A: length 6.7
  TOP w0.2: R19A.2 R18A.2 63.88,46 63.83,45.95 C17A.2 61.7,45.95 61.55,45.8 C15A.2 60.55,46 R16A.1
UNNAMED_1_CAP_I16_N2B: length 6.7
  TOP w0.2: R16B.1 60.55,34 C15B.2 61.55,33.8 61.7,33.95 C17B.2 63.83,33.95 63.88,34 R19B.2 R18B.2
UNNAMED_1_CAP_I16_N2C: length 6.7
  TOP w0.2: R16C.1 60.55,22 C15C.2 61.55,21.8 61.7,21.95 C17C.2 63.83,21.95 63.88,22 R19C.2 R18C.2
UNNAMED_1_CAP_I16_N2D: length 6.7
  TOP w0.2: R16D.1 60.55,10 C15D.2 61.55,9.8 61.7,9.95 C17D.2 63.83,9.95 63.88,10 R19D.2 R18D.2
UNNAMED_1_CAP_I17_N1A: length 6.9
  TOP w0.2: R21A.2 R20A.2 63.88,47.25 63.58,47.55 C17A.1 61.95,47.55 61.55,47.95 C16A.1 60.55,47.75 R17A.1
UNNAMED_1_CAP_I17_N1B: length 6.9
  TOP w0.2: R21B.2 R20B.2 63.88,35.25 63.57,35.55 C17B.1 61.95,35.55 61.55,35.95 C16B.1 60.55,35.75 R17B.1
UNNAMED_1_CAP_I17_N1C: length 6.9
  TOP w0.2: R21C.2 R20C.2 64.12,23.25 63.82,23.55 C17C.1 61.95,23.55 61.55,23.95 C16C.1 60.55,23.75 R17C.1
UNNAMED_1_CAP_I17_N1D: length 6.9
  TOP w0.2: R17D.1 60.55,11.75 C16D.1 61.55,11.95 61.95,11.55 C17D.1 63.58,11.55 63.88,11.25 R20D.2 R21D.2
UNNAMED_1_CAP_I50_N2A: length 7.4
  TOP w0.2: C3A.2 51.88,42.5 51.22,43.15 50.35,43.15 50.25,43.25 R8A.1 R6A.2 49.62,45 48.37,46.25 R4A.2
UNNAMED_1_CAP_I50_N2B: length 7.4
  TOP w0.2: C3B.2 50.95,30.5 50.25,31.2 R8B.1 R6B.2 49.62,33 48.37,34.25 R4B.2
UNNAMED_1_CAP_I50_N2C: length 7.4
  TOP w0.2: C3C.2 50.95,18.5 50.25,19.2 R8C.1 R6C.2 49.62,21 48.37,22.25 R4C.2
UNNAMED_1_CAP_I50_N2D: length 7.4
  TOP w0.2: C3D.2 50.95,6.5 50.25,7.2 R8D.1 R6D.2 49.62,9 48.37,10.25 R4D.2
UNNAMED_1_CAP_I55_N2A: length 7.2
  TOP w0.2: R7A.2 R9A.1 ; R9A.1 50.25,49.08 50.45,48.88 C4A.2 ; R9A.1 49.12,50.25 48.88,50 R5A.1
UNNAMED_1_CAP_I55_N2B: length 7.2
  TOP w0.2: R5B.1 48.88,38 49.12,38.25 R9B.1 ; C4B.2 50.45,36.88 50.25,37.08 R9B.1 ; R9B.1 R7B.2
UNNAMED_1_CAP_I55_N2C: length 7.2
  TOP w0.2: C4C.2 50.45,24.88 50.25,25.07 R9C.1 ; R7C.2 R9C.1 ; R9C.1 49.12,26.25 48.88,26 R5C.1
UNNAMED_1_CAP_I55_N2D: length 7.2
  TOP w0.2: R9D.1 50.25,13.07 50.45,12.88 C4D.2 ; R9D.1 R7D.2 ; R9D.1 49.12,14.25 48.88,14 R5D.1
UNNAMED_1_RES_I12_N1A: length 12.5
  TOP w0.2: R14A.1 R16A.2 56.88,46 56.18,46.69 49.18,46.69 48.37,47.5 R10A.2
UNNAMED_1_RES_I12_N1B: length 12.5
  TOP w0.2: R14B.1 R16B.2 56.88,34 56.18,34.69 49.18,34.69 48.37,35.5 R10B.2
UNNAMED_1_RES_I12_N1C: length 12.5
  TOP w0.2: R10C.2 48.37,23.5 49.18,22.69 56.18,22.69 56.88,22 R16C.2 R14C.1
UNNAMED_1_RES_I12_N1D: length 12.5
  TOP w0.2: R14D.1 R16D.2 56.88,10 56.18,10.69 49.18,10.69 48.37,11.5 R10D.2
UNNAMED_1_RES_I18_N2A: length 12.3
  TOP w0.2: R15A.2 R17A.2 58.37,47.88 49.37,47.88 48.5,48.75 R11A.2
UNNAMED_1_RES_I18_N2B: length 12.3
  TOP w0.2: R11B.2 48.5,36.75 49.37,35.88 58.37,35.88 R17B.2 R15B.2
UNNAMED_1_RES_I18_N2C: length 12.3
  TOP w0.2: R11C.2 48.5,24.75 49.37,23.88 58.37,23.88 R17C.2 R15C.2
UNNAMED_1_RES_I18_N2D: length 12.3
  TOP w0.2: R15D.2 R17D.2 58.37,11.88 49.37,11.88 48.5,12.75 R11D.2
UNNAMED_12_DIOLED_I371_P: length 5.4
  TOP w0.4: DS1.A 73,54.12 73.75,53.38 R1.2
UNNAMED_12_ICM24CXX_I354_E0: length 4.1
  BOTTOM w0.2: R3.2 R4.2 71.38,4 71.91,4.53 U1.1
UNNAMED_12_ICM24CXX_I354_E1: length 4.8
  BOTTOM w0.2: U1.2 70.63,4.88 70,4.25 69.38,4.25 69.12,4 R6.2 R5.2
UNNAMED_12_ICM24CXX_I354_E2: length 5.8
  BOTTOM w0.2: R7.2 R8.2 66.88,4 67.38,4.5 69,4.5 69.37,4.87 U1.3
UNNAMED_21_ADG5421F_I1_S1: length 11.6
  TOP w0.2: J11.1 17,21 14.75,18.75 13,18.75 12.25,18 U3.1 12.25,15.5 v1(12.5,15.25)
UNNAMED_21_ADG5421F_I1_S2: length 11.7
  TOP w0.2: v1(11.25,15.25) 11.75,15.75 U3.2 11.75,18 11,18.75 9.25,18.75 7,21 J12.1
UNNAMED_21_ADG5421F_I24_S1: length 11.4
  TOP w0.2: J9.1 7,36.75 8.75,38.5 11,38.5 11.75,39.25 U2.1 11.75,41.75 v2(11.5,42)
UNNAMED_21_ADG5421F_I24_S2: length 11.5
  TOP w0.2: J10.1 17,36.75 15.38,38.38 13.12,38.38 12.25,39.25 U2.2 12.25,41.5 v2(12.75,42)
VADJ: length 3.7
  TOP w0.2: v1(84.21,34.4) v1(84.21,35.03) ; v1(84.21,34.4) v1(84.21,33.76) P1.D18 ; v1(84.21,34.4) P1.D17 ; v1(84.21,35.03) P1.D16 ; v1(84.21,35.03) v1(84.21,35.67) P1.D15
VIO: length 162.2
  TOP w0.2: P1.C1 v1(82.33,44.56) ; P1.C2 v1(82.33,43.92)
  TOP w0.4: R2.1 v2(72.75,44.12)
  LAYER_3 w0.4: v2(72.75,44.12) 77.12,44.12 80.25,47.25 82.18,47.25 83.04,46.39 83.04,45.26 v1(82.33,44.56)
  LAYER_3 w0.6: v2(42.12,53.35) 41.25,52.47 41.25,42.72 v2(42.62,41.35) 43.38,40.59 43.38,39.34 41.25,37.2 41.25,32.88 42.12,32 v2(42.12,29.35) 41.12,28.35 ; v2(8.03,17.75) 8.03,18.15 8.88,19 10.38,19 11.62,20.25 11.62,37.38 12.62,38.38 14.97,38.38 v2(16.1,39.5) 20.5,39.5 24.62,35.38 29.38,35.38 36.38,28.38 41.1,28.38 41.12,28.35 ; 41.12,28.35 41.12,21.62 42.25,20.5 v2(42.25,17.35)
  LAYER_4 w0.4: v1(82.33,43.92) v1(82.33,44.56) 82.33,44.58 83.25,45.5
  LAYER_4 w0.6: v2(42.12,53.35) 42.88,52.59 42.88,51.34 43.59,50.62 50.25,50.62 53,53.38 63.88,53.38 67.5,49.75 75.5,49.75 77.75,47.5 82.5,47.5 83.25,46.75 83.25,45.5

## Copper pours and planes (outline as drawn)
-12V on BOTTOM: outline of 125 points within 51,4.88 81.75,55
GROUND on LAYER_2, LAYER_5: 0.5,57.5 85.5,57.5 85.5,0.5 0.5,0.5

## Text on the board
Ref Des/Silkscreen Bottom: SECONDARY SIDE
User.Comments: CR_AFE_CHANNEL_3 | CR_AFE_CHANNEL_4 | CR_DAC-GAIN_1
Ref Des/Silkscreen Top: PRIMARY SIDE | 08-070425 REV-B | CHA DAC OUT | CHD DAC OUT | CHC DAC OUT | CHB DAC OUT | POS CHB INPUT NEG | POS CHC INPUT NEG | POS CHA INPUT NEG | POS CHD INPUT NEG | PERSONALITY | HIL | BOARD | EVAL-CN0584-EBZ
XSECTION_CHART: *  SURFACE | L1 TOP CONDUCTOR | *  DIELECTRIC | L2 LAYER_2 CONDUCTOR | L3 LAYER_3 CONDUCTOR | L4 LAYER_4 CONDUCTOR | L5 LAYER_5 CONDUCTOR | L6 BOTTOM CONDUCTOR | DESIGN CROSS SECTION CHART | ___________________________ | TOTAL THICKNESS 1.616 MM | 1-6
DISPLAY_TOP: LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE.
User.15: FILLED VIAS: | COPLANAR ON BOTH SIDES WITHIN .001 INCH PRIOR TO FINAL PLATING. | THRU VIAS FILLED WITH NON-CONDUCTIVE EPOXY AND PLATED OVER.
User.17: LYR-2 (GND PLANE) | 08-      -07
User.18: LYR-3 (POWER/SIG) | 08-      -08
User.19: LYR-4 (POWER/SIG) | 08-      -09
User.20: LYR-5 (GND PLANE) | 08-      -10
User.45: FIGURE | FINISHED_SIZE | 0.2032 | 0.254 | 1.016 | 1.524 | 1.778 | 0.9398 | 3.175 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | NON-PLATED | QTY | 194 | 140 | 4 | 12 | 48 | 2
